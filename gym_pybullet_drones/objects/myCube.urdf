Commit message: first upload

File: gym_pybullet_drones/objects/myCube.urdf (robot description, URDF)
Before this commit: robot cube, 5 links, 4 joints
Links:
- link baseLink: geometry collision box size=2 2 8; visual mesh filename=cube.obj scale=2 2 8
